# Keil uVision project TemperHumidity.uvproj, settings and files
target TemperHumidity (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TemperHumidity +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Source
    ./sources/: STARTUP.A51 main.c stc15Int.c global.c
    ./device/: stc15func.c
  group Doc
    ./doc/: readme.txt
  group Include
    ./include/: comdef.h config.h DHT11.h global.h stc15func.h
  group Device
    ./device/: DHT11.c
